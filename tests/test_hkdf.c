/* Verify OpenShield HKDF-SHA256 against RFC 5869 Test Case 1. */
#include <stdio.h>
#include <string.h>
#include <stdint.h>
#include "../core/hkdf.h"

static const uint8_t ikm[22] = {0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,
                                0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b,0x0b};
static const uint8_t salt[13] = {0x00,0x01,0x02,0x03,0x04,0x05,0x06,0x07,0x08,0x09,0x0a,0x0b,0x0c};
static const uint8_t info[10] = {0xf0,0xf1,0xf2,0xf3,0xf4,0xf5,0xf6,0xf7,0xf8,0xf9};

static const uint8_t exp_prk[32] = {
  0x07,0x77,0x09,0x36,0x2c,0x2e,0x32,0xdf,0x0d,0xdc,0x3f,0x0d,0xc4,0x7b,0xba,0x63,
  0x90,0xb6,0xc7,0x3b,0xb5,0x0f,0x9c,0x31,0x22,0xec,0x84,0x4a,0xd7,0xc2,0xb3,0xe5 };
static const uint8_t exp_okm1[32] = {
  0x3c,0xb2,0x5f,0x25,0xfa,0xac,0xd5,0x7a,0x90,0x43,0x4f,0x64,0xd0,0x36,0x2f,0x2a,
  0x2d,0x2d,0x0a,0x90,0xcf,0x1a,0x5a,0x4c,0x5d,0xb0,0x2d,0x56,0xec,0xc4,0xc5,0xbf };

int main(void)
{
	uint8_t out[32];

	/* one-shot extract+expand */
	os_hkdf_sha256(salt, 13, ikm, 22, info, 10, out);
	if (memcmp(out, exp_okm1, 32) != 0) { printf("FAIL one-shot HKDF\n"); return 1; }
	printf("PASS one-shot HKDF (RFC 5869 TC1)\n");

	/* streaming extract (two-part IKM) then expand */
	{
		os_hmac_sha256_ctx_storage h;
		uint8_t prk[32];
		os_hmac_sha256_init(&h, salt, 13);
		os_hmac_sha256_update(&h, ikm, 11);
		os_hmac_sha256_update(&h, ikm + 11, 11);
		os_hmac_sha256_final(&h, prk);
		if (memcmp(prk, exp_prk, 32) != 0) { printf("FAIL streaming extract\n"); return 1; }
		printf("PASS streaming extract matches PRK\n");

		os_hkdf_expand32(prk, info, 10, out);
		if (memcmp(out, exp_okm1, 32) != 0) { printf("FAIL expand\n"); return 1; }
		printf("PASS expand matches OKM\n");
	}

	printf("\nALL HKDF TESTS PASSED\n");
	return 0;
}
